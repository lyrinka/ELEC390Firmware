# Keil uVision project ELEC390Firmware.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G071CBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ELEC390Firmware +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c include: .\Library;.\Code
  asm include: .\Code;.\Library
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Code
    ./Code/: main.c looper.c looper.h lwtdaq.c lwtdaq.h main2.c mainthread.c mainthread.h blethread.c blethread.h
  group OS
    ./Library/: liblwt.c liblwt.h libhandler.c libhandler.h libscheduler.c libscheduler.h
  group HAL
    ./Library/: libsys.c libsys.h libi2c.c libi2c.h libuartble.c libuartble.h libuart.c libuart.h liblptim.c liblptim.h
  group Protocol
    ./Library/: libpacket.c libpacket.h libprotocol.c libprotocol.h libcodec.c libcodec.h
  group Util
    ./Library/: critregion.h libstream.c libstream.h libstorage.c libstorage.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.4.0
